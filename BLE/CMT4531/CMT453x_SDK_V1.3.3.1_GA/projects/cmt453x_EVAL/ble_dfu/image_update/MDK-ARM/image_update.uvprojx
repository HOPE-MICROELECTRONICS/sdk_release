# Keil uVision project image_update.uvprojx, settings and files
target CMT453x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMT4531 HOPERF
  pack: HOPERF.CMT453x_DFP.1.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x1000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(64000000) ELITTLE
  output: image_update +hex
  AfterMake: fromelf --bin --output=.\bin\image_update.bin .\Objects\image_update.axf
  AfterMake: cmd.exe /C copy .\bin\image_update.bin ..\..\..\..\..\utilities\dfu\Image\ImageUpdate.bin
  c flags: oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CMT453x, USE_STDPERIPH_DRIVER,IMAGE_UPDATE
  c include: ..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\firmware\cmt453x_std_periph_driver\inc;..\inc;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_library\log;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_profile\dis\diss\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ahi\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\hl\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\hl\inc;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\hl\src\gap;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\hl\src\gatt;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\hl\src\l2c;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\ll\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\ll\src;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\ll\src\llc;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\ll\src\lld;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\ll\src\llm;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\em\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\hci\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\sch\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\aes\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\common\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\dbg\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\ecc_p256\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\h4tl\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\ke\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\rwip\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\rfinit\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\arch;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\stack_common;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_library\adv;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_library\timer;..\inc\app_profile;..\inc\rw;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_profile\dis\diss\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_profile\hp_ius\hp_iuss\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_library\dfu;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_library\ecc;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_library\error;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_profile\rdts;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_profile\rdts\rdtss\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_profile\hogp\hogpd\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_profile\hogp\hogpd\src;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_profile\hogp;..\..\common;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_library\delay;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_library\sleep;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_library\sec
  library: MicroLIB
  memory RVCT4: ROM 0x103c000 size 0x4000
  memory RVCT9: RAM 0x20004000 size 0x8000
  link misc: ..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\symdef\symbol_g15.obj
  group STARTUP
    ../../../../../firmware/CMSIS/device/startup/: startup_cmt453x.s
  group CMSIS
    ../../../../../firmware/CMSIS/device/: system_cmt453x.c
  group FWLB
    ../../../../../firmware/cmt453x_std_periph_driver/src/: misc.c cmt453x_crc.c cmt453x_rcc.c cmt453x_gpio.c cmt453x_qflash.c
  group BLE_STACK
    ../../../../../middlewares/HopeRF/ble_library/hp_ble_stack/ip/ble/hl/src/att/: lib_att.c
    ../../../../../middlewares/HopeRF/ble_library/hp_ble_stack/stack_common/: rwip_driver.c rwip.c
  group BLE_PROFILE
    ../../../../../middlewares/HopeRF/ble_library/hp_ble_profile/: prf.c prf_utils.c
    ../../../../../middlewares/HopeRF/ble_library/hp_ble_profile/hp_ius/hp_iuss/src/: hp_iuss.c hp_iuss_task.c
  group Crypto
    ../../../../../middlewares/HopeRF/ble_library/hp_library/ecc/: hp_ecc.c sha256.c uECC.c
  group HP_LIB
    ../../../../../middlewares/HopeRF/ble_library/hp_library/error/: hp_error.c
  group HP_DFU
    ../../common/: dfu_crc.c dfu_delay.c
    ../../../../../middlewares/HopeRF/ble_library/hp_library/dfu/: hp_dfu_ble.c hp_dfu_boot.c
  group BLE_APP
    ../src/app_profile/: app_hp_ius.c
    ../src/: hp_ble.c hp_ble_task.c
  group USER
    ../src/: main.c
  group CONFIG
    ../inc/: app_user_config.h
  group DOC
    ../: readme.txt
