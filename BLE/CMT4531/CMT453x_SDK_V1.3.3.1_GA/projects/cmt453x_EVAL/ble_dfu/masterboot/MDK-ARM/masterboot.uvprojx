# Keil uVision project masterboot.uvprojx, settings and files
target CMT453x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMT4531 HOPERF
  pack: HOPERF.CMT453x_DFP.1.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x1000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(64000000) ELITTLE
  output: masterboot +hex
  AfterMake: fromelf --bin --output=.\bin\masterboot.bin .\Objects\masterboot.axf
  AfterMake: cmd.exe /C copy .\bin\masterboot.bin ..\..\..\..\..\utilities\dfu\Image\MasterBoot.bin
  c flags: oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CMT453x, USE_STDPERIPH_DRIVER,MASTERBOOT
  c include: ..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\firmware\cmt453x_std_periph_driver\inc;..\inc;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_library\error;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_library\dfu;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_library\scheduler;..\..\common
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x2000
  memory RVCT9: RAM 0x20004000 size 0x8000
  group STARTUP
    ../../../../../firmware/CMSIS/device/startup/: startup_cmt453x.s
  group CMSIS
    ../../../../../firmware/CMSIS/device/: system_cmt453x.c
  group FWLB
    ../../../../../firmware/cmt453x_std_periph_driver/src/: misc.c cmt453x_gpio.c cmt453x_rcc.c cmt453x_crc.c cmt453x_usart.c cmt453x_qflash.c
  group USER
    ../src/: main.c
  group HP_LIB
    ../../../../../middlewares/HopeRF/ble_library/hp_library/error/: hp_error.c
    ../../../../../middlewares/HopeRF/ble_library/hp_library/scheduler/: hp_scheduler.c
  group DOC
    ../: readme.txt
  group HP_DFU
    ../../common/: dfu_usart.c dfu_led.c dfu_delay.c dfu_crc.c
    ../../../../../middlewares/HopeRF/ble_library/hp_library/dfu/: hp_dfu_boot.c hp_dfu_serial.c
