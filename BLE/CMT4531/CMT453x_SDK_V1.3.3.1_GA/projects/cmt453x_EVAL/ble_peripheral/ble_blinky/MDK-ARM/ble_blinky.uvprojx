# Keil uVision project ble_blinky.uvprojx, settings and files
target CMT453x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMT4531 HOPERF
  pack: HOPERF.CMT453x_DFP.1.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x1000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(64000000) ELITTLE
  output: lp_timer
  AfterMake: fromelf --bin --output=.\bin\lp_timer.bin .\Objects\lp_timer.axf
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CMT453X, USE_STDPERIPH_DRIVER, SLEEP_LP_TIMER_ENABLE,LSI_TRIM_32768HZ
  c include: ..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\firmware\cmt453x_std_periph_driver\inc;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_profile\dis\diss\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ahi\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\hl\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\hl\inc;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\hl\src\gap;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\hl\src\gatt;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\hl\src\l2c;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\ll\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\ll\src;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\ll\src\llc;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\ll\src\lld;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\ll\src\llm;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\em\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\hci\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\sch\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\aes\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\common\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\dbg\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\ecc_p256\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\h4tl\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\ke\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\rwip\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\rfinit\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\arch;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\common\api;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\common\src;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\stack_common;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\arch;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_library\adv;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_library\timer;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_library\log;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_library\sleep;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_library\delay;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_library\sec;..\inc\app_profile;..\inc;..\..\..\..\..\middlewares\HopeRF\ble_library\hp_library\ble
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x20004000 size 0x8000
  link misc: ..\..\..\..\..\middlewares\HopeRF\ble_library\hp_ble_stack\symdef\symbol_g15.obj
  group STARTUP
    ../../../../../firmware/CMSIS/device/startup/: startup_cmt453x.s
  group CMSIS
    ../../../../../firmware/CMSIS/device/: system_cmt453x.c
  group FWLB
    ../../../../../firmware/cmt453x_std_periph_driver/src/: misc.c cmt453x_adc.c cmt453x_crc.c cmt453x_dma.c cmt453x_exti.c cmt453x_gpio.c cmt453x_rcc.c cmt453x_tim.c cmt453x_usart.c cmt453x_lpuart.c cmt453x_qflash.c cmt453x_rtc.c
  group BLE_STACK
    ../../../../../middlewares/HopeRF/ble_library/hp_ble_stack/stack_common/: rwip.c rwip_driver.c
  group BLE_PROFILE
    ../../../../../middlewares/HopeRF/ble_library/hp_ble_profile/: prf.c prf_utils.c
    ../../../../../middlewares/HopeRF/ble_library/hp_ble_profile/dis/diss/src/: diss.c diss_task.c
  group HP_LIB
    ../../../../../middlewares/HopeRF/ble_library/hp_library/log/: hp_log_lpuart.c hp_log_usart.c
    ../../../../../middlewares/HopeRF/ble_library/hp_library/sleep/: hp_sleep.c
    ../../../../../middlewares/HopeRF/ble_library/hp_library/sec/: hp_sec.c
    ../../../../../middlewares/HopeRF/ble_library/hp_library/ble/: hp_ble.c hp_ble_task.c
    ../../../../../middlewares/HopeRF/ble_library/hp_library/timer/: hp_timer.c
  group BLE_APP
    ../src/app_profile/: app_dis.c
    ../src/: app_ble.c
  group USER
    ../src/: main.c app_lpuart.c app_gpio.c app_rtc.c cmt453x_it.c
  group CONFIG
    ../inc/: app_user_config.h
  group DOC
    ../: readme.txt
target debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMT4531 HOPERF
  pack: HOPERF.CMT453x_DFP.1.1.0
  cpu: as above
  output: dis
  AfterMake: fromelf --bin --output=.\bin\dis.bin .\Objects\dis.axf
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CMT453X, USE_STDPERIPH_DRIVER, SLEEP_LP_TIMER_ENABLE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x20004000 size 0x8000
  link misc: as above
