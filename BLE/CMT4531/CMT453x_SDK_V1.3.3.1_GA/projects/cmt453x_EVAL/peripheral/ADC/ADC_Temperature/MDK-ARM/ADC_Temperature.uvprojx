# Keil uVision project ADC_Temperature.uvprojx, settings and files
target CMT453x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMT4531 HOPERF
  pack: HOPERF.CMT453x_DFP.1.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x1000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(64000000) ELITTLE
  output: ADC_Temperature
  AfterMake: fromelf --bin --output=.\bin\ADC_Temperature.bin .\Objects\ADC_Temperature.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CMT453X, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\cmt453x_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_cmt453x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_cmt453x.c
  group FWLB
    ../../../../../../firmware/cmt453x_std_periph_driver/src/: misc.c cmt453x_adc.c cmt453x_gpio.c cmt453x_rcc.c cmt453x_usart.c cmt453x_dma.c
  group USER
    ../src/: main.c cmt453x_it.c
  group BSP
    ../../../../bsp/src/: log.c
  group DOC
    ../: readme.txt
