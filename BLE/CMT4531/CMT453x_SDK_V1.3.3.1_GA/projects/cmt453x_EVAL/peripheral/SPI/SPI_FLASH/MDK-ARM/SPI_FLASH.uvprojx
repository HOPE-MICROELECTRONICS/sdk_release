# Keil uVision project SPI_FLASH.uvprojx, settings and files
target CMT453x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMT4531 HOPERF
  pack: HOPERF.CMT453x_DFP.1.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x1000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(64000000) ELITTLE
  output: SPI_FLASH +hex
  AfterMake: fromelf --bin --output=.\bin\SPI_FLASH.bin .\Objects\SPI_FLASH.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CMT453x, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\cmt453x_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_cmt453x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_cmt453x.c
  group FWLB
    ../../../../../../firmware/cmt453x_std_periph_driver/src/: cmt453x_gpio.c cmt453x_spi.c cmt453x_rcc.c
  group USER
    ../src/: main.c spi_flash.c cmt453x_it.c
  group DOC
    ../: readme.txt
